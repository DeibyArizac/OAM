options:
  parameters:
    generate_options: qt_gui
    id: oam_complete_flowgraph
    output_language: python
    run_command: python3 -u {filename}
    title: OAM Complete System - Optical Communication via Orbital Angular Momentum
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: oam_channel_0
  id: oam_channel
  parameters:
    cn2: '4e-17'
    propagation_distance: '5'
    snr_target: '30'
  states: {}
- name: oam_decoder_0
  id: oam_decoder
  parameters:
    grid_size: '512'
    rx_aperture_size: '35'
  states: {}
- name: oam_encoder_0
  id: oam_encoder
  parameters:
    grid_size: '512'
    num_oam_modes: '6'
    tx_aperture_size: '35'
    tx_power: '20'
    wavelength: '630'
  states: {}
- name: oam_source_0
  id: oam_source
  parameters:
    data_rate_multiplier: '1.0'
    message_text: UIS
    symbol_rate: '32000'
  states: {}
- name: oam_visualizer_0
  id: oam_visualizer
  parameters:
    dashboard_step_delay: '3.0'
    enable_dashboard_a: 'True'
    enable_dashboard_b: 'True'
    enable_dashboard_c: 'True'
    enable_dashboard_d: 'True'
    enable_dashboard_e: 'True'
  states: {}

connections:
- [oam_channel_0, '0', oam_decoder_0, '0']
- [oam_decoder_0, '0', oam_visualizer_0, '0']
- [oam_encoder_0, '0', oam_channel_0, '0']
- [oam_source_0, '0', oam_encoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
